Commit message: I hate URDF exporter

File: sim_urdf2/urdf/sim_urdf.urdf (robot description, URDF)
Before this commit: robot sim_urdf, 3 links, 2 joints
Links:
- link arm_left: mass 0.0039735 -> 0.0039781
- link arm_right: mass 0.0039735 -> 0.0039781
