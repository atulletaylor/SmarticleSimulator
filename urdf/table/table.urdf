Commit message: urdfs

File: urdf/table/table.urdf (robot description, URDF)
Before this commit: robot table.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=2 2 0.6; visual mesh filename=tabletop.obj scale=0.1 0.1 0.58
